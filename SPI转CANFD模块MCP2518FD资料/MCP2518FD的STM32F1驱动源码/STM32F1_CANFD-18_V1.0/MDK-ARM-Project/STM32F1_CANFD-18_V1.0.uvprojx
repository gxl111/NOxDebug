# Keil uVision project STM32F1_CANFD-18_V1.0.uvprojx, settings and files
target CANFD-18 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CANFD_18 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;..\User;..\Driver;..\Common\CMSIS\CM3\CoreSupport;..\Common\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Common\STM32F10x_StdPeriph_Driver\inc;..\Driver\canfdspi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Setup
    ../Common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group User
    ../User/: main.c stm32f10x_it.c etk_can.c etk_crc8.c
  group Driver
    ../Driver/: etk_usart.c etk_delay.c etk_spi_mcp2517fd.c etk_led.c etk_key.c
    ../Driver/canfdspi/: drv_canfdspi_api.c
  group CMSIS
    ../Common/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group StdPeriph_Driver
    ../Common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Doc
    ./: readme.txt
